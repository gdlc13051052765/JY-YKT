# Keil uVision project ENC28J60.uvprojx, settings and files
target W5500一卡通 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: W5500-一卡通(参数存储)——05 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\RTC;..\HARDWARE\SPI;..\HARDWARE\TIMER;..\APP;..\HARDWARE\BSP;..\HARDWARE\UDP;..\VARIABLEDEF;..\HARDWARE\KEY_1629;..\SYSTEM\gpio;..\POS;..\HARDWARE\AT24C02;..\HARDWARE\AT24C512;..\HARDWARE\SPI-FLASH;..\HARDWARE\BEEP;..\HARDWARE\MFRC522;..\SYSTEM\IIC;..\HARDWARE\PCF8563;..\SYSTEM\DKSPI;..\HARDWARE\485;..\HARDWARE\WATCHDOG;..\SYSTEM\NVIC;..\HARDWARE\AT24C256;..\HARDWARE\AT24C64;..\HARDWARE\W5500;..\HARDWARE\WIFI
  memory RVCT4: ROM 0x8010000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/TIMER/: timerx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/BSP/: BSP.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY_1629/: ScanKeyFiles.C Disp_1629DFile.C
    ../HARDWARE/SPI-FLASH/: SPI_FLASH.C
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/MFRC522/: MFRC522.c MoNiSPI.C
    ../HARDWARE/PCF8563/: PCF8563.C
    ../HARDWARE/485/: 485.C
    ../HARDWARE/WATCHDOG/: watch_dog.c
    ../HARDWARE/AT24C256/: AT24C256.C
    ../HARDWARE/AT24C64/: AT24C64.C
    ../HARDWARE/: BY8001.c
    ../HARDWARE/WIFI/: USR-232.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/gpio/: GPIO.C
    ../SYSTEM/IIC/: iic.c
    ../SYSTEM/DKSPI/: DK_SPI.C
    ../SYSTEM/NVIC/: NVIC.C
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_bkp.c stm32f10x_dbgmcu.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_exti.c
  group VARIABLEDEF
    ../VARIABLEDEF/: VariableDef.h char.H ExternVariableDef.h ExternVoidDef.H MyDefine.H
  group POS
    ../POS/: CalucationFile.c InitSetParameterFile.C CRCFiles.C uart_data_analyse.C ConsumSubFile.C RecordFiles.C ReadSysParameterFile.C MainFile.C M1_CardFiles.C RW_CardFiles.C SerialFiles.C
  group W5500
    ../HARDWARE/W5500/: W5500.c
    ./: UDP_DEMO.c
software components: CMSIS:CORE 5.0.1
